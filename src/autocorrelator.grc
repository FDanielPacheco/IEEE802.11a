options:
  parameters:
    author: pacheco
    generate_options: qt_gui
    id: autocorrelator
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: plateau_level
  id: variable_qtgui_range
  parameters:
    label: Plateau
    min_len: '50'
    start: '1'
    step: '1'
    stop: '32'
    value: '16'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '40000000.0'
  states: {}
- name: trigger_level
  id: variable_qtgui_range
  parameters:
    label: Trigger
    min_len: '50'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: win_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: Threshold Level
    const: trigger_level * (-1)
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    comment: Plateau Minumum
    const: (-1) * plateau_level
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/pacheco/Documents/FEUP/MYREG/DigitalCommunications/IEEE802.11a/dataset/Sample3_20MHz_Channel100.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: win_size
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: win_size+16
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: '16'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: ' trigger_level '
    init: '0'
    low: 'trigger_level - 0.1 '
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    size: '1024'
    srate: samp_rate
    tr_level: trigger_level+0.5
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    size: '1024'
    srate: samp_rate
    tr_level: trigger_level*16
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '16'
    ymin: '0'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: autocorrelator_out
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: delayed_in
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: autocorrelator_out
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: delayed_in
  states: {state: disabled}

connections:
- [blocks_add_const_vxx_0, '0', blocks_threshold_ff_0, '0']
- [blocks_add_const_vxx_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_delay_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_delay_0, '0', virtual_sink_0_0, '0']
- [blocks_divide_xx_0, '0', blocks_null_sink_0, '0']
- [blocks_divide_xx_0, '0', virtual_sink_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_divide_xx_0, '1']
- [blocks_moving_average_xx_1, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_threshold_ff_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_throttle_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [blocks_throttle_0, '0', blocks_delay_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [virtual_source_1, '0', blocks_add_const_vxx_0, '0']
- [virtual_source_1, '0', qtgui_time_sink_x_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
