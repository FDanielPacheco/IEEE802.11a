options:
  parameters:
    author: pacheco
    generate_options: qt_gui
    id: main
    output_language: python
    realtime_scheduling: '1'
    title: Not titled yet
  states: {}

blocks:
- name: att_sink
  id: variable_qtgui_range
  parameters:
    label: Input Waveform Attenuation (Display Only)
    start: '0.00001'
    step: '0.01'
    stop: '1'
    value: '0.01'
  states: {}
- name: att_sink_offset
  id: variable_qtgui_range
  parameters:
    label: Input Waveform Attenuation Offset (Display Only)
    start: '-5'
    step: '0.01'
    stop: '5'
    value: '-0.5'
  states: {}
- name: chan_est
  id: variable_qtgui_chooser
  parameters:
    labels: '["LS", "LMS", "Linear Comb", "STA"]'
    num_opts: '0'
    options: '[0, 1, 2, 3]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: dif_lo
  id: variable_qtgui_range
  parameters:
    label: Diference between LO
    min_len: '50'
    start: '0.99'
    step: '0.000001'
    stop: '1'
    value: '1'
  states: {}
- name: encoding
  id: variable_qtgui_chooser
  parameters:
    labels: '["BPSK 1/2", "BPSK 3/4", "QPSK 1/2", "QPSK 3/4", "16QAM 1/2", "16QAM 3/4", "64QAM 2/3", "64QAM 3/4"]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5, 6, 7]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: fir_win
  id: variable_qtgui_chooser
  parameters:
    label: FIR Window Size
    labels: '[''16'', ''32'', ''48'', ''64'', ''80'']'
    num_opts: '0'
    options: '[16,32,48,64,80]'
    type: real
    value: '48'
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    labels: '[''  1 | 2412.0 | 11g'', ''  2 | 2417.0 | 11g'', ''  3 | 2422.0 | 11g'', ''  4 | 2427.0 | 11g'', ''  5 | 2432.0 | 11g'', ''  6 | 2437.0 | 11g'', ''  7 | 2442.0 | 11g'', ''  8 | 2447.0 | 11g'', ''  9 | 2452.0 | 11g'', '' 10 | 2457.0 | 11g'', '' 11 | 2462.0 | 11g'', '' 12 | 2467.0 | 11g'', '' 13 | 2472.0 | 11g'', '' 14 | 2484.0 | 11g'', '' 34 | 5170.0 | 11a'', '' 36 | 5180.0 | 11a'', '' 38 | 5190.0 | 11a'', '' 40 | 5200.0 | 11a'', '' 42 | 5210.0 | 11a'', '' 44 | 5220.0 | 11a'', '' 46 | 5230.0 | 11a'', '' 48 | 5240.0 | 11a'', '' 50 | 5250.0 | 11a'', '' 52 | 5260.0 | 11a'', '' 54 | 5270.0 | 11a'', '' 56 | 5280.0 | 11a'', '' 58 | 5290.0 | 11a'', '' 60 | 5300.0 | 11a'', '' 62 | 5310.0 | 11a'', '' 64 | 5320.0 | 11a'', ''100 | 5500.0 | 11a'', ''102 | 5510.0 | 11a'', ''104 | 5520.0 | 11a'', ''106 | 5530.0 | 11a'', ''108 | 5540.0 | 11a'', ''110 | 5550.0 | 11a'', ''112 | 5560.0 | 11a'', ''114 | 5570.0 | 11a'', ''116 | 5580.0 | 11a'', ''118 | 5590.0 | 11a'', ''120 | 5600.0 | 11a'', ''122 | 5610.0 | 11a'', ''124 | 5620.0 | 11a'', ''126 | 5630.0 | 11a'', ''128 | 5640.0 | 11a'', ''132 | 5660.0 | 11a'', ''134 | 5670.0 | 11a'', ''136 | 5680.0 | 11a'', ''138 | 5690.0 | 11a'', ''140 | 5700.0 | 11a'', ''142 | 5710.0 | 11a'', ''144 | 5720.0 | 11a'', ''149 | 5745.0 | 11a (SRD)'', ''151 | 5755.0 | 11a (SRD)'', ''153 | 5765.0 | 11a (SRD)'', ''155 | 5775.0 | 11a (SRD)'', ''157 | 5785.0 | 11a (SRD)'', ''159 | 5795.0 | 11a (SRD)'', ''161 | 5805.0 | 11a (SRD)'', ''165 | 5825.0 | 11a (SRD)'', ''172 | 5860.0 | 11p'', ''174 | 5870.0 | 11p'', ''176 | 5880.0 | 11p'', ''178 | 5890.0 | 11p'', ''180 | 5900.0 | 11p'', ''182 | 5910.0 | 11p'', ''184 | 5920.0 | 11p'']'
    num_opts: '0'
    options: '[2412000000.0, 2417000000.0, 2422000000.0, 2427000000.0, 2432000000.0, 2437000000.0, 2442000000.0, 2447000000.0, 2452000000.0, 2457000000.0, 2462000000.0, 2467000000.0, 2472000000.0, 2484000000.0, 5170000000.0, 5180000000.0, 5190000000.0, 5200000000.0, 5210000000.0, 5220000000.0, 5230000000.0, 5240000000.0, 5250000000.0, 5260000000.0, 5270000000.0, 5280000000.0, 5290000000.0, 5300000000.0, 5310000000.0, 5320000000.0, 5500000000.0, 5510000000.0, 5520000000.0, 5530000000.0, 5540000000.0, 5550000000.0, 5560000000.0, 5570000000.0, 5580000000.0, 5590000000.0, 5600000000.0, 5610000000.0, 5620000000.0, 5630000000.0, 5640000000.0, 5660000000.0, 5670000000.0, 5680000000.0, 5690000000.0, 5700000000.0, 5710000000.0, 5720000000.0, 5745000000.0, 5755000000.0, 5765000000.0, 5775000000.0, 5785000000.0, 5795000000.0, 5805000000.0, 5825000000.0, 5860000000.0, 5870000000.0, 5880000000.0, 5890000000.0, 5900000000.0, 5910000000.0, 5920000000.0]'
    type: real
    value: '2417000000'
  states: {}
- name: interval
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '1000'
    step: '1'
    stop: '100000'
    value: '5000'
  states: {}
- name: jammer_amp
  id: variable_qtgui_range
  parameters:
    label: Jammer Amplitude
    start: '0'
    step: '0.1'
    stop: '100'
    value: '1'
  states: {}
- name: jammer_bandwidth
  id: variable_qtgui_range
  parameters:
    label: Jammer Bandwidth
    start: 1e6
    step: 0.5e6
    stop: 200e6
    value: 1e6
  states: {}
- name: jammer_freq
  id: variable_qtgui_range
  parameters:
    label: Jammer Freq.
    start: 1e3
    step: 0.1e3
    stop: 20e6
    value: 1e3
  states: {}
- name: lo_offset
  id: variable_qtgui_chooser
  parameters:
    num_opts: '3'
    option0: '0'
    option1: 6e6
    option2: 11e6
    type: real
    value: '0'
  states: {}
- name: max_symbols
  id: variable
  parameters:
    value: int(5 + 1 + ((16 + 800 * 8 + 6) * 2) / 24)
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    label: Noise Level (dBm)
    min_len: '50'
    start: '-200'
    step: '0.1'
    stop: '0'
    value: '-120'
  states: {}
- name: noise_v
  id: variable
  parameters:
    value: 10**(noise/10)
  states: {}
- name: out_buf_size
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: pdu_length
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '1500'
    value: '500'
  states: {}
- name: plateau_n
  id: variable_qtgui_range
  parameters:
    label: Plateau Number
    min_len: '50'
    start: '1'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    start: '0'
    step: '0.01'
    stop: '74.5'
    value: '61'
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    label: Sample Rate
    labels: '["5 MHz", "10 MHz", "20 MHz"]'
    num_opts: '0'
    options: '[5e6, 10e6, 20e6]'
    type: real
    value: 20e6
  states: {}
- name: snr
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    start: '-15'
    step: '0.1'
    stop: '30'
    value: '15'
  states: {}
- name: sync_length
  id: variable_qtgui_chooser
  parameters:
    label: Long Sync Length
    labels: '[''240'',''320'']'
    num_opts: '0'
    options: '[240,320]'
    type: real
    value: '320'
  states: {}
- name: trigger_level
  id: variable_qtgui_range
  parameters:
    label: Plateau Trigger
    min_len: '50'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.7'
  states: {}
- name: trigger_power
  id: variable_qtgui_range
  parameters:
    label: Trigger Power Level
    min_len: '50'
    start: '1e-6'
    step: '1e-6'
    stop: '1'
    value: '1e-4'
    widget: counter
  states: {}
- name: tx_att
  id: variable_qtgui_range
  parameters:
    label: TX Attenuation
    start: '0'
    step: '0.01'
    stop: '100'
    value: '1'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.75'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: 'jammer_bandwidth / 1e6 '
    freq: jammer_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: att_sink_offset
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    comment: Calculate signal power
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: Preamble Size
    delay: '16'
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: sync_length
    type: complex
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: '1200'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    comment: Autocorrelator output
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/wifi_rx.pcap
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/wifi_tx.pcap
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/pacheco/Documents/FEUP/MYREG/DigitalCommunications/IEEE802.11a/dataset/Sample3_20MHz_Channel100.bin
    offset: '50000000'
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("".join(chr(i) for i in range(ord('A'), ord('Z')+1)) * (pdu_length // 26 + 1))
    period: interval
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: fir_win
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: fir_win+16
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    comment: |-
      Short Preamble 
      Detection Section
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.6'
    minoutbuf: '100000'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      This implementation has two limitations:
      - The number of samples copied after detecting
        a frame is limited by a fixed maximum length,
        which constrains the maximum frame that can
        be decoded
      - Second, during the "copy" state the block does
        not monitor the autocorrelation metric, which
        means that additional frames arriving shortly 
        after the first one will be missed.

      Solution implemented for second problem:
      - Inside the "copy" state of the finite state machi-
        ne, also check the metric of autocorrelation, and
        if another plateau is detected mark it down, this
        way frames with a short time-lag, e.g., CTS or RTS
        are not missed.
    const: '1'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_3
  id: blocks_multiply_const_vxx
  parameters:
    const: att_sink
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: (10**(snr/10.0))**.5
    type: complex
  states: {}
- name: blocks_multiply_const_xx_1
  id: blocks_multiply_const_xx
  parameters:
    const: jammer_amp
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    minoutbuf: max_symbols * 48 * 8
    ninputs: '2'
    tag_preserve_head_pos: '1'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: jammer_amp
    samp_rate: samp_rate
    sensitivity: 1e6
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: dif_lo
    freq_offset: '0.0'
    noise_voltage: '1'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    minoutbuf: max_symbols * 48 * 8 * 2
    out_type: complex
    symbol_table: '[-1, 1]'
  states: {}
- name: digital_ofdm_carrier_allocator_cvc_0_0_0
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    fft_len: '64'
    len_tag_key: '"packet_len"'
    minoutbuf: max_symbols * 48 * 8
    occupied_carriers: (list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) +list( range(22, 27)),)
    output_is_shifted: 'True'
    pilot_carriers: ((-21, -7, 7, 21), )
    pilot_symbols: ((1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1))
    sync_words: ((0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0), (0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0), (0, 0j, 0, 0j, 0, 0j, -1, 1j, -1, 1j, -1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, (-0-1j), 1, -1j, -1, 1j, 0, -1j, 1, (-0-1j), 1, -1j, 1, 1j, -1, -1j, 1, (-0-1j), -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 0j, 0, 0j, 0, 0j), (0, 0, 0, 0, 0, 0, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 0, 0, 0, 0))
  states: {}
- name: digital_ofdm_cyclic_prefixer_0_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: '16'
    input_size: '64'
    minoutbuf: max_symbols * 48 * 8 * 10
    rolloff: '2'
    tagname: '"packet_len"'
  states: {}
- name: digital_packet_headergenerator_bb_0
  id: digital_packet_headergenerator_bb
  parameters:
    header_formatter: ieee802_11.signal_field().formatter()
    len_tag_key: '"packet_len"'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      # Autor: Fábio D. Pacheco
      # Date: 21/11

      import numpy as np
      from gnuradio import gr

      S_IDLE    = 0
      S_PACKET  = 1

      class basic_block(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__( self, power_thres=0.01, window_size=80 ):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Power Threshold Filter',   # will show up in GRC
                  in_sig=[np.complex64, np.float32],   
                  out_sig=[np.complex64, np.float32]   

              )
              self.power_thres  = power_thres
              self.window_size  = window_size

              self.state        = S_IDLE
              self.sample_count = 0
              
          def work(self, input_items, output_items):
              xin   = input_items[0]   # complex signal
              xmag2 = input_items[1]   # power (or magnitude^2)
              nin   = len(xin)

              output_items[0][:] = 0
              output_items[1][:] = 0

              nout = 0

              for i in range( nin ): 
                  mag = xmag2[i]

                  if( S_IDLE == self.state ):
                      if mag > self.power_thres:
                          self.sample_count = 0
                          self.state = S_PACKET
                      else:
                          continue

                  if( S_PACKET == self.state ):
                      output_items[0][i] = xin[i]
                      output_items[1][i] = mag
                      nout += 1
                                      
                      if mag < self.power_thres:
                          self.sample_count += 1
                          if self.sample_count > self.window_size:
                              self.state = S_IDLE
                      else:
                          self.sample_count = 0

              self.consume_each(nin)
              return nout
    comment: |-
      Filter low power signals,
      unless a packet appear to 
      be starting.
    power_thres: trigger_power
    window_size: '80'
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    comment: |-
      The basic channel bandwidth in 
      IEEE 802.11a/g/n is 20 MHz
      Further divided in 64-sub carriers
       (0.3125 MHz each).

      Sub-carrier organization:
      - The unused are in the ranges of:
          [-32,-27], [DC/0] and  [27, 32]
      - The pilot subcarriers are single in:
         [-21], [-7], [7] and [21]
      - The data carring subcarriers are:
         [-26,-22], [-20, -8],  [-6, 1] , [1,6], 
         [8, 20] and [22, 26]
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(64)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'False'
    minoutbuf: max_symbols * 48 * 8 * 10
    shift: 'True'
    type: complex
    window: tuple([1/52**.5] * 64)
  states: {}
- name: foo_packet_pad2_0
  id: foo_packet_pad2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    minoutbuf: out_buf_size * 10
    pad_front: '500'
    pad_tail: '0'
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '127'
  states: {}
- name: foo_wireshark_connector_0_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '127'
  states: {}
- name: ieee802_11_chunks_to_symbols_xx_0
  id: ieee802_11_chunks_to_symbols_xx
  parameters:
    minoutbuf: max_symbols * 48 * 8
  states: {}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    comment: |-
      Demodulation:
      - Each OFDM data subcarrier is demodulated into
        1, 2, 4, or 6 bits per subcarrier (NBPSC) depending on the modulation 
        (BPSK, QPSK, 16-QAM, or 64-QAM).

      Deinterleaving:
      - The coded bits inside each OFDM symbol were 
        interleaved at the transmitter using two permutations:
        =: Permutation 1: spreads adjacent coded bits across different subcarriers
          (protects against frequency-selective fades)
        =: Permutation 2: spreads significant bits (e.g., MSBs of QAM symbols)
            across different positions (protects constellation decision boundaries)

      This block reverses both permutations and restores the 
      original coded bit order.

      Convolutional Decoding:
      - The deinterleaved bits are passed to the Viterbi decoder, which
       reconstructs the original scrambled bitstream according to the 
      selected coding rate (1/2, 2/3, or 3/4).

      Descrambling:
      - A 7-bit LFSR descrambler removes the PHY-layer scrambling 
      and produces the PSDU bytes.

      CRC Check:
      - The 32-bit CRC (FCS) at the end of the PSDU is verified.
      Frames with incorrect CRC are dropped.

      PDU Output:
      - On success, a PDU containing the MAC payload and metadata 
      (timestamps,channel info, modulation, etc.) is published to the
      output message port.
    debug: 'False'
    log: 'False'
  states: {}
- name: ieee802_11_frame_equalizer_0
  id: ieee802_11_frame_equalizer
  parameters:
    algo: ieee802_11.Equalizer(chan_est)
    bw: samp_rate
    comment: |-
      The Frame Equalizer takes time-aligned OFDM symbols 
      and compensates sampling and residual frequency offsets 
      using pilots, then equalizes subcarriers and decodes the 
      SIGNAL field. First, each symbol is corrected for sampling 
      frequency/phase error using a coarse offset from the sync 
      stage plus a slowly updated residual. The four pilot tones 
      (with symbol-dependent BPSK polarity) are used to compute
       and remove a common phase rotation and to estimate a 
      residual frequency error which is tracked with an IIR filter. 

      The chosen equalizer (COMB, LS, LMS or STA) then estimates 
      the channel and equalizes the 48 data subcarriers. The SIGNAL
      symbol is decoded (deinterleaving → Viterbi) to determine 
      modulation and frame length; metadata and CSI are published
      as tags/messages. The block outputs equalized data subcarriers 
      ready for demapping and decoding.
    debug: 'False'
    freq: freq
    log: 'False'
  states: {}
- name: ieee802_11_mac_0
  id: ieee802_11_mac
  parameters:
    bss_mac: '[0xff, 0xff, 0xff, 0xff, 0xff, 255]'
    dst_mac: '[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]'
    src_mac: '[0x23, 0x23, 0x23, 0x23, 0x23, 0x23]'
  states: {}
- name: ieee802_11_mapper_0
  id: ieee802_11_mapper
  parameters:
    debug: 'False'
    encoding: ieee802_11.Encoding(encoding)
  states: {}
- name: ieee802_11_parse_mac_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'True'
    log: 'False'
  states: {}
- name: ieee802_11_parse_mac_0_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: ieee802_11_sync_long_0
  id: ieee802_11_sync_long
  parameters:
    comment: |-
      Performs a cross-correlation between the Long Training 
      Sequence (LTS) and the incoming signal to detect the 
      repeated LTS structure. The block correlates the input 
      with a 64-sample LTS pattern and collects a window of 
      SYNC_LENGTH correlation results.

      From this correlation window, the block finds the strongest 
      peaks and searches for peak pairs spaced by 63, 64, or 65
      samples, corresponding to the two repeated LTS symbols. 
      The best pair determines the frame start, and the phase 
      difference between the peaks yields the fine CFO correction.

      After detecting the frame start, the block enters the COPY 
      state. It begins forwarding samples from the delayed input
      to the output, starting at the estimated frame boundary, 
      while inserting a wifi_start tag at the exact alignment point. 
      A continuous fine CFO correction of is applied during copy:

      s''[n] = s'[n] ⋅ exp( j⋅n⋅freq_offset )

      The block suppresses the Sync Short and Sync Long preamble 
      samples by only outputting data after the LTS region; therefore,
      the output stream begins directly at the first OFDM data symbol.
    debug: 'False'
    log: 'False'
    sync_length: sync_length
  states: {}
- name: ieee802_11_sync_short_0
  id: ieee802_11_sync_short
  parameters:
    comment: |-
      Search for a valid start-of-frame:
      - Detect when the correlation exceeds a threshold for MIN_PLATEAU 
        consecutive samples.

      Declare the beginning of a packet:
      - When the plateau is detected, tag the sample index (wifi_start) and 
        measure the coarse CFO using the phase of the autocorrelation.

      Copy the packet payload region:
      - Begin outputting samples while skipping the short-training repeated
        part; copy up to MAX_SAMPLES (540 x 80) symbols corresponding to 
        the full OFDM frame.

      Coarse CFO correction:
      - During the copying stage, apply exponential correction to compensate
        for oscillator mismatch.

      s'[n] = s[n]⋅exp( -j⋅cfo⋅n)

      Detect additional frames during COPY:
      - If another correlation plateau is found after MIN_GAP samples, restart 
        the process, allowing detection of back-to-back packets.
    debug: 'False'
    log: 'False'
    min_plateau: plateau_n
    threshold: trigger_level
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_att
    bandwidth: '40000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: freq
    samplerate: int(samp_rate)
    type: fc32
    uri: 10.227.144.100
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: freq
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: 10.227.144.100
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    color1: '"black"'
    gui_hint: (12,0,1,1)
    legend: 'False'
    name: Input PDU
    size: 48*10
    type: complex
    update_time: '10'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    color1: '"black"'
    gui_hint: (12,1,1,1)
    legend: 'False'
    name: Output PDU
    size: 48*10
    type: complex
    update_time: '10'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    color1: '"black"'
    fc: '0'
    fftsize: '1024'
    gui_hint: (13,0,1,1)
    legend: 'False'
    name: Antenna TX Spectrum
    type: complex
    update_time: '10'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color1: black
    color3: red
    color4: blue
    gui_hint: (14,0,1,1)
    label1: Autocorrelation
    label2: 'Null '
    label3: Input Waveform Real
    label4: Input Waveform Imag
    legend: 'False'
    marker2: '0'
    marker3: '0'
    name: Autocorrelation , Input Waveform
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    style2: '0'
    style4: '0'
    tr_level: trigger_level
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    update_time: '10'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    color1: black
    color3: red
    color4: blue
    entags: 'False'
    gui_hint: (14,1,1,1)
    label1: Autocorrelation
    label2: 'Null '
    label3: Input Waveform Real
    label4: Input Waveform Imag
    legend: 'False'
    marker2: '0'
    marker3: '0'
    name: Autocorrelation , Input Waveform
    nconnections: '2'
    size: '20000'
    srate: samp_rate
    style2: '0'
    style4: '0'
    tr_level: trigger_level
    type: complex
    update_time: '10'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    color1: black
    gui_hint: (13,1,1,1)
    legend: 'False'
    name: Antenna TX Time Evo.
    size: '160'
    srate: samp_rate
    type: complex
    update_time: '10'
    ymax: '3'
    ymin: '-3'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: input_data
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: output_corr
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: input_corr
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: input_delayed
  states: {}
- name: virtual_sink_2_0_0
  id: virtual_sink
  parameters:
    stream_id: frame_vector
  states: {}
- name: virtual_sink_2_0_0_0
  id: virtual_sink
  parameters:
    stream_id: gen_tx
  states: {}
- name: virtual_sink_2_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: mac_out
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: jammer_out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    comment: |-
      Meaningfull data is defined as:
      - Preamble duration is 8 u[s].
      - Sampling rate 20 M[Samples/s]
      - 10 repeating sequence of 16 I/Q samples
      - 160 samples in total
    stream_id: input_data
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: gen_tx
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: mac_out
  states: {}
- name: virtual_source_1_0_0_1
  id: virtual_source
  parameters:
    stream_id: input_delayed
  states: {}
- name: virtual_source_1_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: input_corr
  states: {}
- name: virtual_source_1_0_0_1_1
  id: virtual_source
  parameters:
    stream_id: frame_vector
  states: {}
- name: virtual_source_1_0_0_1_2
  id: virtual_source
  parameters:
    stream_id: input_delayed
  states: {}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: output_corr
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: jammer_out
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_vco_f_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_add_xx_0, '0', channels_channel_model_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_delay_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_delay_0, '0', virtual_sink_2_0, '0']
- [blocks_delay_0_0, '0', ieee802_11_sync_long_0, '1']
- [blocks_delay_1, '0', blocks_throttle_0, '0']
- [blocks_divide_xx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_divide_xx_0, '0', virtual_sink_1, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_float_to_complex_1, '0', blocks_add_xx_0, '1']
- [blocks_message_strobe_0_0, strobe, ieee802_11_mac_0, app in]
- [blocks_moving_average_xx_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_moving_average_xx_0, '0', virtual_sink_2, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_divide_xx_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', foo_packet_pad2_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_complex_to_mag_squared_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_delay_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', ieee802_11_sync_long_0, '0']
- [blocks_multiply_const_vxx_3, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_xx_1, '0', virtual_sink_3, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [blocks_stream_to_vector_0, '0', virtual_sink_2_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_2_0_0_0_0, '0']
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [blocks_vco_f_0, '0', blocks_multiply_const_xx_1, '0']
- [channels_channel_model_0, '0', blocks_delay_1, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_ofdm_carrier_allocator_cvc_0_0_0, '0', fft_vxx_0_0, '0']
- [digital_ofdm_cyclic_prefixer_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [digital_ofdm_cyclic_prefixer_0_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_ofdm_cyclic_prefixer_0_0, '0', qtgui_time_sink_x_1, '0']
- [digital_packet_headergenerator_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [fft_vxx_0, '0', ieee802_11_frame_equalizer_0, '0']
- [fft_vxx_0_0, '0', digital_ofdm_cyclic_prefixer_0_0, '0']
- [foo_packet_pad2_0, '0', virtual_sink_2_0_0_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [foo_wireshark_connector_0_0, '0', blocks_file_sink_0_0, '0']
- [ieee802_11_chunks_to_symbols_xx_0, '0', blocks_tagged_stream_mux_0, '1']
- [ieee802_11_chunks_to_symbols_xx_0, '0', qtgui_const_sink_x_0, '0']
- [ieee802_11_decode_mac_0, out, ieee802_11_parse_mac_0, in]
- [ieee802_11_frame_equalizer_0, '0', ieee802_11_decode_mac_0, '0']
- [ieee802_11_frame_equalizer_0, symbols, pdu_pdu_to_tagged_stream_0, pdus]
- [ieee802_11_mac_0, phy out, blocks_message_debug_0, print]
- [ieee802_11_mac_0, phy out, ieee802_11_mapper_0, in]
- [ieee802_11_mac_0, phy out, ieee802_11_parse_mac_0_0, in]
- [ieee802_11_mapper_0, '0', digital_packet_headergenerator_bb_0, '0']
- [ieee802_11_mapper_0, '0', ieee802_11_chunks_to_symbols_xx_0, '0']
- [ieee802_11_parse_mac_0, out, foo_wireshark_connector_0, in]
- [ieee802_11_parse_mac_0_0, out, foo_wireshark_connector_0_0, in]
- [ieee802_11_sync_long_0, '0', blocks_stream_to_vector_0, '0']
- [ieee802_11_sync_short_0, '0', blocks_multiply_const_vxx_1, '0']
- [iio_pluto_source_0, '0', virtual_sink_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', qtgui_const_sink_x_0_0, '0']
- [virtual_source_0, '0', blocks_delay_0, '0']
- [virtual_source_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [virtual_source_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [virtual_source_0_0, '0', blocks_multiply_const_xx_0, '0']
- [virtual_source_0_0, '0', iio_pluto_sink_0, '0']
- [virtual_source_1, '0', digital_ofdm_carrier_allocator_cvc_0_0_0, '0']
- [virtual_source_1_0_0_1, '0', ieee802_11_sync_short_0, '0']
- [virtual_source_1_0_0_1_0, '0', ieee802_11_sync_short_0, '1']
- [virtual_source_1_0_0_1_1, '0', fft_vxx_0, '0']
- [virtual_source_1_0_0_1_2, '0', blocks_multiply_const_vxx_3, '0']
- [virtual_source_1_1, '0', ieee802_11_sync_short_0, '2']
- [virtual_source_2, '0', blocks_float_to_complex_1, '0']
- [virtual_source_2, '0', blocks_float_to_complex_1, '1']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
